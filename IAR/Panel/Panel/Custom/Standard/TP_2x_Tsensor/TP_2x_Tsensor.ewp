# IAR project TP_2x_Tsensor.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x50
  General.SCCStackSize: 0x50
  General.SCRStackSize: 35
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: __TP020; __HW0323
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../../../System/: main.c
  group Atmel_Hardware
    ../../../Hardware_Atmel/: functions.c
    ../../../Hardware_Atmel/I2C/: i2c.c
  group Custom
    Custom/: custom.c lcd_page_turn_on.c
    Menu_new/: lcd_menu.c lcd_page_0.c lcd_page_1.c lcd_page_2.c lcd_page_3.c lcd_page_4.c lcd_page_adjust.c lcd_page_day_night.c lcd_page_min_protok.c lcd_page_season.c
  group Custom/No_Compile
    Menu_new/: dimmer.c lcd_alarm_confirm.c lcd_alarm_password.c lcd_cell.c lcd_screen_0.c
  group Graphics
    ../../../System/Bmp/: bmp.c
    ../../../System/T6963/: T6963.c
    ../../../System/TSC2046/: tsc2046.c
  group IO
    ../../../System/IO/: io.c
  group MODBus_Slave
    ../../../System/Misc/: crc_modbus.c
    ../../../System/MODBUS_Slave/: MODBUS_S_functions.c MODBUS_S_protocol.c
  group RS485_Master
    ../../../System/RS485_Master/: RS485_M_functions.c RS485_M_protocol.c
  group RS485_Slave
    ../../../System/RS485_Slave/: RS485_S_functions.c RS485_S_protocol.c
  group Screens
    ../../../System/Menu_new/: lcd_calibrate.c lcd_set_time.c lcd_tech_contrast.c lcd_tech_menu.c lcd_tech_temperature.c lcd_template.c
  group Service
    ../../../System/Misc/: crc.c
    ../../../System/Service/: service.c
    ../../../System/Timer/: timer16.c
  group TMP441
    ../../../System/TMP441/: TMP441.c
  group Uart
    ../../../System/Uart/: str.c
