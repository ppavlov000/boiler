# IAR project boot_controller_rs232.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  AAVR.ADefines: INCLUDE_FILE="iom128.h"; SPMREG=SPMCSR; __RAMPZ__; __MEMSPM__
  XLINK.XclFile: W:\Ura\Projects\20100322_Clean\IAR\Boot_Controller_Console\mb.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group Common sources
    ./: console.c iflash.c main.c spm.asm timer16.c xmodem.c
    Include/: crc.c fram31xx.c i2c.c str.c
