# IAR project boot_controller_rs485.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _CV0323_
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  AAVR.ADefines: INCLUDE_FILE="iom128.h"; SPMREG=SPMCSR; __RAMPZ__; __MEMSPM__
  XLINK.XclFile: mb.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
  group Common sources
    Include/: crc.c
    ./: iflash.c main.c str.c timer16.c
  group Common sources/Hardware
    ./: functions.c spm.asm
  group Common sources/Mem
    Include/: fram31xx.c i2c.c
  group Common sources/RS485_Slave
    RS485_Slave/: uart_functions.c uart_protocol.c
