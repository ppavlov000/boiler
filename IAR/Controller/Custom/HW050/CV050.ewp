# IAR project CV050.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x80
  General.SCRStackSize: 35
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: __HW050; __COMPILER2
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ../../System/: main.c
  group Compiler
    ../../System/Compiler/: compiler.c compiler_goto.c compiler_logic.c compiler_math.c compiler_misc.c
  group Compiler2
    ../../System/Compiler2/: compiler2.c compiler2_goto.c compiler2_math.c
  group Console
    ../../System/Console/: console.c str.c
  group Custom
    Custom/: custom.c fancoil.c
  group Hardware
    ../../Hardware_Atmel/: functions.c lcd.c
    ../../Hardware_Atmel/I2C/: i2c.c
    Hardware/: io.c
  group IO
    ../../System/IO/: adc.c
  group Misc
    ../../System/Misc/: crc.c
  group RS485_Slave
    ../../System/RS485_Slave/: RS485_S_functions.c RS485_S_protocol.c
  group System
    ../../System/Service/: errors.c plm.c test.c
    ../../System/Timer/: timer16.c
    ../../System/Xmodem/: xmodem.c
  group System/Kotel
    ../../System/Kotel/: kotel.c
  group System/LCD
    LCD_Menu/: menu.c menu_custom_pid.c menu_custom_timer.c menu_errors.c menu_info.c menu_language.c menu_parameters.c menu_password.c menu_pid.c menu_program.c menu_program_mode.c menu_time.c
  group System/Memory
    ../../System/Memory/: fram31xx.c
  group System/PID
    ../../System/Pid/: pid.c
  group System/TMP441
    ../../System/TMP441/: TMP441.c
  group System/Valve_3t
    ../../System/Valve_3t/: valve_3t.c
